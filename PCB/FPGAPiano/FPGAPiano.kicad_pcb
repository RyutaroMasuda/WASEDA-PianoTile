# Repository RyutaroMasuda/WASEDA-PianoTile

File README.md:

# 動いている様子 (押したらリンク飛べます)

# ハードウェアの説明

# quarutus

DE10-Nano + FPGAPiano シールド（回路図 rev2）向けの **ピンアサイン／極性確認用 Quartus Prime プロジェクト**です。
シールド上の各出力（行・列・7セグ・桁・プログレスバー・緑LED）が正しい端子と正しい極性で光るかどうかを、
実機上で目視確認するためのテスト回路 `pin_test_top` を収録しています。

## 構成

| ファイル/フォルダ | 内容 |
|---|---|
| `pin_test_top.v` | トップモジュール（Verilog）。ピン確認用のスキャン表示ロジック |
| `pin_test.qpf` | Quartus Prime プロジェクトファイル（Revision: `pin_test`） |
| `pin_test.sdc` | タイミング制約（50MHz クロック、入出力は目視確認用のため false path） |
| `pin_test.sof` | コンパイル済みコンフィギュレーションファイル（FPGA書き込み用） |
| `pin_test.cdf` | JTAG書き込み用チェインファイル |
| `pin_test.pin` | Fitter によるピン配置結果（レポート用） |
| `pin_test.fit.rpt` / `pin_test.map.rpt` / `pin_test.sta.rpt` 等 | Fit/Map/タイミング解析レポート |
| `FPGAPiano_sch_rev2.pdf` | FPGAPianoシールドの回路図（rev2） |
| `FIX_NOTES.md` | ピン配置ミスや出力極性の調整履歴（修正ログ） |
| `db/`, `incremental_db/` | Quartus Prime のコンパイル中間生成物（自動生成） |

## 対象デバイス

- ボード: **Terasic DE10-Nano**
- FPGA: **Intel Cyclone V `5CSEBA6U23I7`**
- 開発環境: **Quartus Prime 25.1 std (Lite Edition)**

## `pin_test_top` の動作概要

`mode_sw[2:0]`（タクトスイッチ、押した瞬間だけHigh）で表示モードを切り替えます。
モードは押している間だけでなく、次に別のスイッチが押されるまで保持されます。

| モード | 状態名 | 内容 |
|---|---|---|
| `mode_sw[0]` 立ち上がり | `ST_ROWCOL` | 行×列（LEDマトリクス）を1本ずつ順にスキャン点灯 |
| `mode_sw[1]` 立ち上がり | `ST_DIGSEG` | 桁×7セグメントを1本ずつ順にスキャン点灯 |
| `mode_sw[2]` 立ち上がり | `ST_BAR` | プログレスバー（10本）を1本ずつ順に点灯 |

また、`sw_in[0:3]` を押している間は、対応する行の位置で緑LED（`m_c8g`）が点灯します。
通常表示（行×列）とスイッチ表示（緑LED）は、内部で高速に時分割（phase切り替え）されており、
互いに干渉せず同時に見えるようになっています。

### モジュールI/O

```verilog
module pin_test_top #(
    parameter CLK_HZ  = 50_000_000,
    parameter AL_ROW  = 0, // 行の出力極性 (1=Active Low)
    parameter AL_COL  = 0, // 列の出力極性
    parameter AL_SEG  = 0, // 7セグの出力極性
    parameter AL_DIG  = 0, // 桁の出力極性
    parameter AL_BAR  = 0, // バーの出力極性
    parameter STEP_HZ = 5  // 1ステップ(1本点灯)を切り替える速度[Hz]
)(
    input  wire        clk,
    input  wire        rst_n,
    input  wire [3:0]  sw_in,     // 緑LED手動点灯用スイッチ
    input  wire [2:0]  mode_sw,   // 表示モード切替スイッチ

    output wire [3:0]  m_r,       // 行
    output wire [9:0]  m_c,       // 列
    output wire        m_c8g,     // 緑LED
    output wire [6:0]  seg,       // 7セグメント
    output wire [3:0]  dig,       // 7セグ桁選択
    output wire [9:0]  p          // プログレスバー
);
```

### 出力の極性（実機確認済み）

| グループ | 駆動方式 | 極性 | パラメータ |
|---|---|---|---|
| 行 `m_r` | PチャネルFET (ハイサイド) | Active Low | `AL_ROW = 1` |
| 列 `m_c` | DRV777 (シンク) | Active High | `AL_COL = 0` |
| 緑 `m_c8g` | DRV777 (シンク) | Active High | `AL_COL = 0` |
| 7セグ `seg` | PチャネルFET | Active Low | `AL_SEG = 1` |
| 桁 `dig` | (暫定) | Active Low | `AL_DIG = 1` |
| バー `p` | (暫定) | Active High | `AL_BAR = 0` |

実機で光り方がおかしい場合は、光らないグループの `AL_xxx` パラメータを反転して再コンパイルしてください
（詳細な調整手順は [`FIX_NOTES.md`](./FIX_NOTES.md) を参照）。

## ピン割り当て（抜粋）

Fitter 結果（`pin_test.pin`）に基づく主要信号のピン配置です。

| 信号 | ピン |
|---|---|
| `clk` | V11 |
| `rst_n` | AH17 |
| `sw_in[0]` | AG15 |
| `sw_in[1]` | AE20 |
| `sw_in[2]` | AE19 |
| `sw_in[3]` | AE17 |
| `mode_sw[0]` | Y15 |
| `mode_sw[1]` | AC24 |
| `mode_sw[2]` | AH19 |

行 (`m_r`)・列 (`m_c`)・7セグ (`seg`)・桁 (`dig`)・バー (`p`)・緑LED (`m_c8g`) の全ピンは
`pin_test.pin` を参照してください。ハードウェア側の詳細な信号対応は `FPGAPiano_sch_rev2.pdf` を参照してください。

## 使い方

1. Quartus Prime 25.1 (Lite Edition以上) で `pin_test.qpf` を開く
2. 必要に応じて `pin_test_top.v` の `AL_xxx` パラメータを調整
3. Compile（Analysis & Synthesis → Fitter → Assembler）を実行し、`pin_test.sof` を生成
4. DE10-NanoにFPGAPianoシールドを接続した状態で、JTAG経由（`pin_test.cdf`）で書き込み
5. `mode_sw` でモードを切り替えながら、各出力が正しい位置・正しい極性で光ることを確認

## 実装状況（コンパイル結果より）

- Fitter: **Successful**
- Logic utilization: 78 / 41,910 ALMs（1%未満）
- Total registers: 85
- Total pins: 45 / 314（14%）
- 動作クロック: 50MHz（`create_clock -period 20.000`）

## 既知の修正履歴

過去に発生したピン配置エラーや極性の確定経緯は [`FIX_NOTES.md`](./FIX_NOTES.md) にまとめられています。

- `sw_in[1]/sw_in[3]/rst_n` のGPIOテーブル読み取りミスによるFitterエラーの修正
- `m_c8g` のビット幅誤り（4bit→1bit、DRV777は1入力のため）の修正
- 各出力グループの極性（Active High/Low）の実機確認による確定

# PCBデータ
KiCad 9.0で作成しています。

## 注意
DE10-nanoのGPIOだけでドットマトリクス/7セグを駆動するとDE10-nano側が燃えそうだったので、外部電源が必須の仕様となっています。電源電圧は5V想定です。  
プログレスバーとスイッチはGPIOに直結のため、外部電源不要で動作可能です。

## 修正事項
7セグの配線に間違いがあり、ラベル名と7セグのピン名が入れ替わっている部分がありますが、公開しているverilogのピンアサインで動くように修正してあります（動くはずです）。

# ライセンス

このプロジェクトは [MIT License](./LICENSE) の下で公開されています。
改変・再配布・商用利用を含め自由に利用できます（著作権表示とライセンス文の保持のみ必須）。

## KiCad design PCB/FPGAPiano/FPGAPiano.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: 100n; C_Disc_D4.7mm_W2.5mm_P5.00mm
DS1: D0; DIPS1524W51P254L1255H800Q10N; Manufacturer_Part_Number OSL10561-LW/LB/LG/LYG/LY/LR/LRA
DS2: D1; DIPS1524W51P254L1255H800Q10N; Manufacturer_Part_Number OSL10561-LW/LB/LG/LYG/LY/LR/LRA
DS3: D2; DIPS1524W51P254L1255H800Q10N; Manufacturer_Part_Number OSL10561-LW/LB/LG/LYG/LY/LR/LRA
DS4: D3; DIPS1524W51P254L1255H800Q10N; Manufacturer_Part_Number OSL10561-LW/LB/LG/LYG/LY/LR/LRA
IC1, IC2, IC3, IC4: DRV777DR; SOIC127P600X175-16N; Manufacturer_Part_Number DRV777DR; Mouser Part Number 595-DRV777DR
J1: GPIO0; PinSocket_2x20_P2.54mm_Vertical
J2: GPIO1; PinSocket_2x20_P2.54mm_Vertical
J3: 5VIN; PinSocket_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11: IRLML2246TRPBF; SOT-23_Handsoldering
R2, R4, R6, R8, R10, R12, R14, R16, R18, R20, R22, R73, R75, R77, R79, R81, R83, R85: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R23, R24, R25, R26, R27, R28, R29, R30, R31, R33, R72, R74, R76, R78, R80, R82, R84: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R32: 300R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R62, R63, R64, R65, R66, R67, R68, R69, R70, R71: 510R; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
SW1: sw_0; SW_PUSH-12mm_Wuerth-430476085716
SW2: sw_1; SW_PUSH-12mm_Wuerth-430476085716
SW3: sw_2; SW_PUSH-12mm_Wuerth-430476085716
SW4: sw_3; SW_PUSH-12mm_Wuerth-430476085716
SW5: mode_0; SW_Tactile_Straight_KSA0Axx1LFTR
SW6: mode_1; SW_Tactile_Straight_KSA0Axx1LFTR
SW7: mode_2; SW_Tactile_Straight_KSA0Axx1LFTR
U1: Upper; LTP-12188M-08
U2: Lower; LTP-12188M-08
U3: YHC05HRK

Connections:
7_a: IC3.2 (IN2), J1.18
7_b: IC3.3 (IN3), J1.19
7_c: IC3.4 (IN4), J1.20
7_d: IC3.5 (IN5), J1.21
7_d0: IC4.2 (IN2), J1.25
7_d1: IC4.3 (IN3), J1.26
7_d2: IC4.4 (IN4), J1.27
7_d3: IC4.5 (IN5), J1.28
7_e: IC3.6 (IN6), J1.22
7_f: IC3.7 (IN7), J1.23
7_g: IC4.1 (IN1), J1.24
+3V3: J2.29, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2
+5V: J3.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), R2.1, R4.1, R6.1, R8.1, R10.1, R12.1, R14.1, R16.1, R18.1, R20.1, R22.1
/7_a_d: Q5.3 (D), R38.2, R45.2, R52.2, R59.2
/7_a_gate: IC3.15 (OUT2), Q5.1 (G), R10.2
/7_b_d: Q6.3 (D), R40.2, R47.2, R54.2, R61.2
/7_b_gate: IC3.14 (OUT3), Q6.1 (G), R12.2
/7_c_d: Q7.3 (D), R35.1, R42.1, R49.1, R56.1
/7_c_gate: IC3.13 (OUT4), Q7.1 (G), R14.2
/7_d0_d: DS1.3 (COMMON_CATHODE_1), DS1.8 (COMMON_CATHODE_2), IC4.15 (OUT2)
/7_d1_d: DS2.3 (COMMON_CATHODE_1), DS2.8 (COMMON_CATHODE_2), IC4.14 (OUT3)
/7_d2_d: DS3.3 (COMMON_CATHODE_1), DS3.8 (COMMON_CATHODE_2), IC4.13 (OUT4)
/7_d3_d: DS4.3 (COMMON_CATHODE_1), DS4.8 (COMMON_CATHODE_2), IC4.12 (OUT5)
/7_d_d: Q8.3 (D), R36.1, R43.1, R50.1, R57.1
/7_d_gate: IC3.12 (OUT5), Q8.1 (G), R16.2
/7_e_d: Q9.3 (D), R34.1, R41.1, R48.1, R55.1
/7_e_gate: IC3.11 (OUT6), Q9.1 (G), R18.2
/7_f_d: Q10.3 (D), R39.2, R46.2, R53.2, R60.2
/7_f_gate: IC3.10 (OUT7), Q10.1 (G), R20.2
/7_g_d: Q11.3 (D), R37.2, R44.2, R51.2, R58.2
/7_g_gate: IC4.16 (OUT1), Q11.1 (G), R22.2
/m_c_0_d: IC1.12 (OUT5), R23.2
/m_c_1_d: IC1.11 (OUT6), R24.2
/m_c_2_d: IC1.10 (OUT7), R25.2
/m_c_3_d: IC2.16 (OUT1), R26.2
/m_c_4_d: IC2.15 (OUT2), R27.2
/m_c_5_d: IC2.14 (OUT3), R28.2
/m_c_6_d: IC2.13 (OUT4), R29.2
/m_c_7_d: IC2.12 (OUT5), R30.2
/m_c_8_d: IC2.11 (OUT6), R31.2
/m_c_8g_d: IC2.10 (OUT7), R32.2
/m_c_9_d: IC3.16 (OUT1), R33.2
/m_r_0_d: Q1.3 (D), U1.19 (R2), U1.22 (R1), U2.19 (R2), U2.22 (R1)
/m_r_0_gate: IC1.16 (OUT1), Q1.1 (G), R2.2
/m_r_1_d: Q2.3 (D), U1.13 (R4), U1.16 (R3), U2.13 (R4), U2.16 (R3)
/m_r_1_gate: IC1.15 (OUT2), Q2.1 (G), R4.2
/m_r_2_d: Q3.3 (D), U1.3 (R5), U1.6 (R6), U2.3 (R5), U2.6 (R6)
/m_r_2_gate: IC1.14 (OUT3), Q3.1 (G), R6.2
/m_r_3_d: Q4.3 (D), U1.9 (R7), U1.12 (R8), U2.9 (R7), U2.12 (R8)
/m_r_3_gate: IC1.13 (OUT4), Q4.1 (G), R8.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, IC1.8 (GND), IC2.8 (GND), IC3.8 (GND), IC4.8 (GND), J1.12, J1.30, J2.12, J2.30, J3.1, R73.1, R75.1, R77.1, R79.1, R81.1, R83.1, R85.1, U3.11 (COM)
unnamed: DS1.7 (ANODE_A), R36.2
unnamed: DS1.6 (ANODE_B), R34.2
unnamed: DS1.4 (ANODE_C), R39.1
unnamed: DS1.2 (ANODE_D), R38.1
unnamed: DS1.1 (ANODE_E), R40.1
unnamed: DS1.9 (ANODE_F), R35.2
unnamed: DS1.10 (ANODE_G), R37.1
unnamed: DS2.7 (ANODE_A), R43.2
unnamed: DS2.6 (ANODE_B), R41.2
unnamed: DS2.4 (ANODE_C), R46.1
unnamed: DS2.2 (ANODE_D), R45.1
unnamed: DS2.1 (ANODE_E), R47.1
unnamed: DS2.9 (ANODE_F), R42.2
unnamed: DS2.10 (ANODE_G), R44.1
unnamed: DS3.7 (ANODE_A), R50.2
unnamed: DS3.6 (ANODE_B), R48.2
unnamed: DS3.4 (ANODE_C), R53.1
unnamed: DS3.2 (ANODE_D), R52.1
unnamed: DS3.1 (ANODE_E), R54.1
unnamed: DS3.9 (ANODE_F), R49.2
unnamed: DS3.10 (ANODE_G), R51.1
unnamed: DS4.7 (ANODE_A), R57.2
unnamed: DS4.6 (ANODE_B), R55.2
unnamed: DS4.4 (ANODE_C), R60.1
unnamed: DS4.2 (ANODE_D), R59.1
unnamed: DS4.1 (ANODE_E), R61.1
unnamed: DS4.9 (ANODE_F), R56.2
unnamed: DS4.10 (ANODE_G), R58.1
unnamed: R72.2, SW1.1
unnamed: R74.2, SW2.1
unnamed: R76.2, SW3.1
unnamed: R78.2, SW4.1
unnamed: R80.2, SW5.1
unnamed: R82.2, SW6.1
unnamed: R84.2, SW7.1
unnamed: R23.1, U1.23 (C1_R)
unnamed: R24.1, U1.20 (C2_R)
unnamed: R25.1, U1.17 (C3_R)
unnamed: R26.1, U1.14 (C4_R)
unnamed: R27.1, U1.2 (C5_R)
unnamed: R28.1, U1.5 (C6_R)
unnamed: R29.1, U1.8 (C7_R)
unnamed: R30.1, U1.11 (C8_R)
unnamed: R32.1, U2.24 (C1_G)
unnamed: R31.1, U2.23 (C1_R)
unnamed: R33.1, U2.20 (C2_R)
unnamed: R62.2, U3.1 (A1)
unnamed: R63.2, U3.2 (A2)
unnamed: R64.2, U3.3 (A3)
unnamed: R65.2, U3.4 (A4)
unnamed: R66.2, U3.5 (A5)
unnamed: R67.2, U3.6 (A6)
unnamed: R68.2, U3.7 (A7)
unnamed: R69.2, U3.8 (A8)
unnamed: R70.2, U3.9 (A9)
unnamed: R71.2, U3.10 (A10)
m_c_0: IC1.5 (IN5), J1.5
m_c_1: IC1.6 (IN6), J1.6
m_c_2: IC1.7 (IN7), J1.7
m_c_3: IC2.1 (IN1), J1.8
m_c_4: IC2.2 (IN2), J1.9
m_c_5: IC2.3 (IN3), J1.10
m_c_6: IC2.4 (IN4), J1.13
m_c_7: IC2.5 (IN5), J1.14
m_c_8: IC2.6 (IN6), J1.15
m_c_8g: IC2.7 (IN7), J1.16
m_c_9: IC3.1 (IN1), J1.17
m_r_0: IC1.1 (IN1), J1.1
m_r_1: IC1.2 (IN2), J1.2
m_r_2: IC1.3 (IN3), J1.3
m_r_3: IC1.4 (IN4), J1.4
mode_0: C5.1, J2.1, R80.1, R81.2
mode_1: C6.1, J2.2, R82.1, R83.2
mode_2: C7.1, J2.3, R84.1, R85.2
p_0: J2.19, R62.1
p_1: J2.20, R63.1
p_2: J2.21, R64.1
p_3: J2.22, R65.1
p_4: J2.23, R66.1
p_5: J2.24, R67.1
p_6: J2.25, R68.1
p_7: J2.26, R69.1
p_8: J2.27, R70.1
p_9: J2.28, R71.1
sw_0: C1.1, J2.37, R72.1, R73.2
sw_1: C2.1, J2.38, R74.1, R75.2
sw_2: C3.1, J2.39, R76.1, R77.2
sw_3: C4.1, J2.40, R78.1, R79.2

Notes on the sheet:
direct drive
もしくは DMG3415U
7セグの出力ピンの名称が入れ替わっているので注意されたい

Board: 2 copper layers, 100.0 x 100.0 mm, 113 parts (13 on the bottom side), 139 nets.
